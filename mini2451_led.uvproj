# Keil uVision project mini2451_led.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: S3C2416 Samsung
  cpu: IRAM(0x40000000-0x4000FFFF) IROM(0x00000000-0x00007FFF) CPUTYPE(ARM926EJ-S)
  output: mini2451_led
  AfterMake: fromelf.exe --bin -o output/@l.bin output/@l.axf
  c flags: Optim=1
  memory RVCT4: ROM 0x0 size 0x8000
  memory RVCT9: RAM 0x40000000 size 0x10000
  scatter file: .\output\Mini2451_Demo.sct
  link misc: --diag_suppress=L6314w
  group Source Group 1
    ./: min2451_led.s main.c clock.c uart.c uart.h app.h printf.c types.h printf.h my_vsprintf.c nand.c nand.h lcd.c lcd.h fanbingbing.c char.c irq.c irq.h 2440slib.h 2440slib.s mmu.h mmu.c typedef.h timer.c timer.h RTC.c RTC.h gbk.c tu1.c tu2.c tu3.c tu4.c tu5.c tu6.c tu7.c album.c album.h uart_irq.c uart_irq.h tu8.c led.c led.h
